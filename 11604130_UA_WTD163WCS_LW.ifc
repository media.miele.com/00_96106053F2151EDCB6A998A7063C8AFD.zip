Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-05-19T12:27:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 19 12:27:28 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\5e170bef-5898-4396-9bbb-24bf36ae5980\07677686-28c5-492d-9a33-f606177ab3f3\ifc * Database version: 5507 * Database creation date: Thu May 19 12:27:27 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 19 12:27:27 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 19 12:27:27 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11604130_UA_WTD163WCS_LW:11TD1631_UA_11604130_WTD163WCS_LW, (2)
In: Default
Type - Material: z_Miele_Design_Cast
Type - Pset_BuildingElementProxyCommon - Reference: 11TD1631_UA_11604130_WTD163WCS_LW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 11TD1631_UA_11604130_WTD163WCS_LW
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 637 mm
Material: z_Miele_Design_Cast, z_Miele_Design_BRWS, z_Miele_Design_Glass, z_Miele_Connection_Gas, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Water_IN, z_Miele_Connection_Water_OUT
Pset_BuildingElementProxyCommon - sets with these values: 2
